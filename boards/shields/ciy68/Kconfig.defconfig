## boards/shields/ciy68/Kconfig.defconfig
```kconfig
if SHIELD_MY_KEYBOARD

config ZMK_KEYBOARD_NAME
    default "ciy68"

endif

CONFIG_ZMK_STUDIO_LOCKING=n
CONFIG_BT=n
```
